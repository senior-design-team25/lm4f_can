# Keil uVision project network_lm4f.uvproj, settings and files
target RASDemo (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RASDemo
  c flags: Optim=1
  c include: ..\;..\..\;C:\;..\StellarisWare;..\..\StellarisWare;C:\StellarisWare;inc;C:\StellarisWare;utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=ResetHandler --first=__Vectors --datacompressor=off
  group Source
    ./: Main.c Startup.c
    C:/StellarisWare/utils/: uartstdio.c
  group Libs
    ../RASLib/output/: RASLib.lib
