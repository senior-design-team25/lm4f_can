# Keil uVision project simple_CAN_rx.uvproj, settings and files
target CAN_rx (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: simple_CAN_rx
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..\;..\..\;C:\;..\StellarisWare;..\..\StellarisWare;C:\StellarisWare;inc;C:\StellarisWare;utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s simple_rx_lm4f.c
